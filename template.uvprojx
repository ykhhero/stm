# Keil uVision project template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Src\core;.\Src\library;.\Src\library\inc;.\Src\User;.\Src\system\delay;.\Src\system\sys;.\Src\system\usart;.\Src\sim800c;.\Src\system\utility;.\Src\system\debug;.\Src\hardware\BEEP;.\Src\hardware\EXTI;.\Src\hardware\KEY;.\Src\hardware\LED;.\Src\system\memory;.\Src\UCOSII\CONFIG;.\Src\UCOSII\CORE;.\Src\UCOSII\PORT
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ./Src/core/: core_cm3.c startup_stm32f10x_hd.s
  group library
    ./Src/library/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ./Src/User/: main.c stm32f10x_it.c system_stm32f10x.c
    ./Src/user/: task.c
  group system
    ./Src/system/delay/: delay.c
    ./Src/system/sys/: sys.c
    ./Src/system/usart/: usart.c
    ./Src/system/utility/: utility.c base64.c
    ./Src/system/debug/: debug.c
    ./Src/system/memory/: memory.c
  group mqtt
    ./Src/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c transport.c pub0sub1.c
  group sim800c
    ./Src/sim800c/: sim800c.c
  group hardware
    ./Src/hardware/BEEP/: beep.c
    ./Src/hardware/EXTI/: exti.c
    ./Src/hardware/KEY/: key.c
    ./Src/hardware/LED/: led.c
  group UCOSII_CORE
    ./Src/UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII_PORT
    ./Src/UCOSII/PORT/: os_cpu_c.c os_cpu.h os_cpu_a.asm
  group UCOSII_CONFIG
    ./Src/UCOSII/CONFIG/: includes.h os_cfg.h
